$begin 'AnsoftProject'
	Created='Thu Oct 15 23:05:23 2026'
	Product='ElectronicsDesktop'
	FileOwnedByWorkbench=false
	$begin 'Desktop'
		Version(2026, 1)
		InfrastructureVersion(1, 0)
		$begin 'FactoryHeader'
			$begin 'geometry3deditor'
				KernelVersion(2, 0)
				ProjectContainsGeometry3D='0'
			$end 'geometry3deditor'
		$end 'FactoryHeader'
	$end 'Desktop'
	UsesAdvancedFeatures=false
	PreviewImageDesignId=1
	NextUniqueID=0
	MoveBackwards=false
	$begin 'HFSSEnvironment'
		Version(1, 0)
	$end 'HFSSEnvironment'
	$begin 'PlanarEMEnvironment'
		Version(1, 0)
	$end 'PlanarEMEnvironment'
	$begin 'Q3DEnvironment'
		Version(1, 0)
	$end 'Q3DEnvironment'
	$begin '2DExtractorEnvironment'
		Version(1, 0)
	$end '2DExtractorEnvironment'
	$begin 'NexximEnvironment'
		Version(1, 0)
	$end 'NexximEnvironment'
	$begin 'NexximNetlistEnvironment'
		Version(1, 0)
	$end 'NexximNetlistEnvironment'
	$begin 'EmitEnvironment'
		Version(1, 0)
	$end 'EmitEnvironment'
	$begin 'Maxwell3DEnvironment'
		Version(1, 0)
	$end 'Maxwell3DEnvironment'
	$begin 'Maxwell2DEnvironment'
		Version(1, 0)
	$end 'Maxwell2DEnvironment'
	$begin 'RMxprtEnvironment'
		Version(1, 0)
	$end 'RMxprtEnvironment'
	$begin 'MaxCirEnvironment'
		Version(1, 0)
	$end 'MaxCirEnvironment'
	$begin 'SimplorerEnvironment'
		Version(1, 0)
	$end 'SimplorerEnvironment'
	$begin 'IcepakEnvironment'
		Version(1, 0)
	$end 'IcepakEnvironment'
	$begin 'IcepakFEAEnvironment'
		Version(1, 0)
	$end 'IcepakFEAEnvironment'
	$begin 'SchematicEnvironment'
		Version(1, 0)
	$end 'SchematicEnvironment'
	$begin 'geometry3deditor'
		Version(1, 0)
	$end 'geometry3deditor'
	ReadVersion=12
	$begin 'DesignMgrEnvironment'
		CompInstCounter=3
		GPortCounter=0
		NetCounter=0
		Alias('Ieee;Simplorer Elements\\Ieee', 'Std;Simplorer Elements\\Std', 'Basic_VHDLAMS;Simplorer Elements\\Basic Elements VHDLAMS\\Basic Elements VHDLAMS', 'Digital_Elements;Simplorer Elements\\Digital Elements\\Digital Elements', 'Transformations;Simplorer Elements\\Tools\\Transformations\\Transformations', 'HEV_VHDLAMS;Simplorer Elements\\HEV VHDLAMS\\HEV VHDLAMS', 'automotive_vda;Simplorer Elements\\VDALibs VHDLAMS\\automotive_vda', 'example_boardnet;Simplorer Elements\\VDALibs VHDLAMS\\example_boardnet', 'example_ecar;Simplorer Elements\\VDALibs VHDLAMS\\example_ecar', 'fundamentals_vda;Simplorer Elements\\VDALibs VHDLAMS\\fundamentals_vda', 'hybrid_emc_vda;Simplorer Elements\\VDALibs VHDLAMS\\hybrid_emc_vda', 'megma;Simplorer Elements\\VDALibs VHDLAMS\\megma', 'modelica_rotational;Simplorer Elements\\VDALibs VHDLAMS\\modelica_rotational', 'modelica_thermal;Simplorer Elements\\VDALibs VHDLAMS\\modelica_thermal', 'modelica_translational;Simplorer Elements\\VDALibs VHDLAMS\\modelica_translational', 'spice2vhd;Simplorer Elements\\VDALibs VHDLAMS\\spice2vhd', 'spice2vhd_devices;Simplorer Elements\\VDALibs VHDLAMS\\spice2vhd_devices', 'aircraft_electrical_vhdlams;Simplorer Elements\\Aircraft Electrical VHDLAMS\\Aircraft Electrical VHDLAMS', 'power_system_vhdlams;Simplorer Elements\\Power System VHDLAMS\\Power System VHDLAMS')
	$end 'DesignMgrEnvironment'
	$begin 'ProjectDatasets'
		NextUniqueID=0
		MoveBackwards=false
		DatasetType='ProjectDatasetType'
		$begin 'DatasetDefinitions'
		$end 'DatasetDefinitions'
	$end 'ProjectDatasets'
	VariableOrders[0:]
	$begin 'Definitions'
		$begin 'Materials'
		$end 'Materials'
		$begin 'SurfaceMaterials'
		$end 'SurfaceMaterials'
		$begin 'Scripts'
		$end 'Scripts'
		$begin 'AnsysComponents'
			NextUniqueID=0
			MoveBackwards=false
			$begin 'AnsysComponentDefinitions'
			$end 'AnsysComponentDefinitions'
		$end 'AnsysComponents'
		$begin 'Symbols'
			$begin 'ground_earth'
				ModTime=1016213689
				Library='Symbols'
				ModSinceLib=false
				LibLocation='SysLibrary'
				HighestLevel=1
				Normalize=true
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('n1', 0, 0.00254, 4.71239, 'N', 0, 0, false, 0, true, '', false, false, 'n1', true)
				$end 'PinDef'
				$begin 'Graphics'
					Line(0, 1, 12566272, -4.33681e-19, 0.00254, -4.33681e-19, 4.33681e-19, End=0, Join=0, LineStyle=0, BeginObj=0, EndObj=0)
					Line(0, 1, 12566272, 0.0017145, -4.33681e-19, -0.0017145, -4.33681e-19, End=0, Join=0, LineStyle=0, BeginObj=0, EndObj=0)
					Line(0, 1, 12566272, -0.001143, -0.000762, 0.001143, -0.000762, End=0, Join=0, LineStyle=0, BeginObj=0, EndObj=0)
					Line(0, 1, 12566272, -0.0005715, -0.001524, 0.0005715, -0.001524, End=0, Join=0, LineStyle=0, BeginObj=0, EndObj=0)
				$end 'Graphics'
			$end 'ground_earth'
			$begin 'ECE_Reference'
				ModTime=1792076723
				CE=2
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=true
				InitialLevels(0, 1)
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0.00254, 0.00254, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, 0.000423333333333333, 0.00254, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'ECE_Reference'
			$begin 'ECE3_Model'
				ModTime=1390507240
				Library='Maxwell Circuit Elements\\MaxCir'
				ModSinceLib=false
				LibLocation='SysLibrary'
				HighestLevel=1
				Normalize=true
				InitialLevels(0, 1)
				$begin 'Graphics'
					$begin '1'
						Rect(0, 0, 12566272, 0, -0.000381, 0, 0.01143, 0.006096, 12566272, 0, 8192)
						Text(-0.00127, 0.00127, 0, 0, 7, false, 'Arial', 12566272, 'Model', false, false, ExtentRect(0, 0, 12566272, 0, 0.00152437134504042, 3.5277777772839e-05, 0.00558874269008083, 0.00246944444445432, 12566272, 0, 0))
						Line(0, 1, 12566272, -0.005842, 0, -0.00508, 0, End=512, Join=8192, LineStyle=0, BeginObj=0, EndObj=0)
						Circle(7.62e-05, 0, 12566272, -0.00381, 0, 0.00127, 12566272)
						Line(0, 1, 12566272, -0.005842, 0.000508, -0.0049784, 0.000508, End=512, Join=8192, LineStyle=0, BeginObj=0, EndObj=0)
						Line(0, 1, 12566272, -0.005842, -0.000508, -0.0049784, -0.000508, End=512, Join=8192, LineStyle=0, BeginObj=0, EndObj=0)
					$end '1'
				$end 'Graphics'
			$end 'ECE3_Model'
			$begin 'ECER_Model'
				ModTime=1390576808
				Library='Maxwell Circuit Elements\\MaxCir'
				ModSinceLib=false
				LibLocation='SysLibrary'
				HighestLevel=1
				Normalize=true
				InitialLevels(0, 1)
				$begin 'Graphics'
					$begin '1'
						Rect(0, 0, 12566272, 0, -0.000381, 0, 0.01143, 0.006096, 12566272, 0, 8192)
						Text(-0.00127, 0.00127, 0, 0, 7, false, 'Arial', 12566272, 'Model', false, false, ExtentRect(0, 0, 12566272, 0, 0.00152437134504042, 3.5277777772839e-05, 0.00558874269008083, 0.00246944444445432, 12566272, 0, 0))
						Circle(7.62e-05, 1, 12566272, -0.00381, 0, 0.000762, 12566272)
						Circle(7.62e-05, 0, 12566272, -0.00381, 0, 0.00127, 12566272)
					$end '1'
				$end 'Graphics'
			$end 'ECER_Model'
		$end 'Symbols'
		$begin 'DefInfo'
			ECE_Reference(0, 0, '', 1792076723, '', 'ECE_Reference', '', '', '', '', '', 'Design.bmp', '', 'Project', '', '', 1792076723, '', 0)
			ECE3_Model(0, 0, 'Ansoft built-in component', 1608235801, '', 'Maxwell Circuit Elements\\MaxCir:ECE3_Model', '', '', 'ECE 3-Phase Model', 'ECE3Model.htm', 'maxcir.chm', 'ece.bmp', 'Maxwell Circuit Elements\\Dedicated Elements', 'SysLibrary', '', '', 1320171096, '', 0)
			ECER_Model(0, 0, 'Ansoft built-in component', 1608235951, '', 'Maxwell Circuit Elements\\MaxCir:ECER_Model', '', '', 'ECE Rotation Model', 'ECERModel.htm', 'maxcir.chm', 'ece.bmp', 'Maxwell Circuit Elements\\Dedicated Elements', 'SysLibrary', '', '', 1320171096, '', 0)
		$end 'DefInfo'
		$begin 'Compdefs'
			$begin 'ECE_Reference'
				Library=''
				CircuitEnv=2
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				$begin 'Properties'
					TextProp('Representation', 'SRD', '', 'ECE_Reference')
					TextProp('Owner', 'SRD', '', 'Maxwell Circuit')
				$end 'Properties'
				CompExtID=1
			$end 'ECE_Reference'
			$begin 'ECE3_Model'
				Library='Maxwell Circuit Elements\\Dedicated Elements'
				CircuitEnv=2
				Refbase='U'
				NumParts=1
				ModSinceLib=false
				CompExtID=1
				$begin 'Parameters'
					TextProp('DeviceName', 'D', 'Device name for ECE 3-phase model', 'ECE3_Model1')
					TextProp('Windings', 'D', 'Comma-separated phase winding list in sequence order', '')
					TextProp('CurrentSweeps', 'D', 'Positive current amplitude sweeping list. Format "v1, v2, (dv1, n1), v3, (dv2, n2), v4, ..."', '(1A, 10)')
					NumberProp('PhAngIntervals', 'D', '(0, 1, 2) for DQ sweeps; 3 for 2-phase sweeps; (>=12) for current & phase angle sweeps, where the value is the number of sweep intervals for phase angle from 0 to 360 electric degrees.', 2, false)
					VariablePropNU('Res', 'HD', 'Phase resistance', '1mOhm', 'ohm', AdditionalPropInfo='')
					VariablePropNU('IndE', 'HD', 'Phase end leakage inductance', '1uH', 'H', AdditionalPropInfo='')
					ButtonProp('MaxCirNetList', 'HD', '', '.MODEL @DeviceName ECE3 (Windings=@Windings Sweeps=@CurrentSweeps PAngN=@PhAngIntervals Res=@Res Ind=@IndE)', '.MODEL @DeviceName ECE3 (Windings=@Windings Sweeps=@CurrentSweeps PAngN=@PhAngIntervals Res=@Res Ind=@IndE)', 1, ButtonPropClientData())
				$end 'Parameters'
			$end 'ECE3_Model'
			$begin 'ECER_Model'
				Library='Maxwell Circuit Elements\\Dedicated Elements'
				CircuitEnv=2
				Refbase='U'
				NumParts=1
				ModSinceLib=false
				CompExtID=1
				$begin 'Parameters'
					TextProp('DeviceName', 'D', 'Device name for ECE Rotation model', 'ECER_Model1')
					VariablePropNU('RotAngMax', 'D', 'Maximum rotating angle for sweeping in mech. or elec. degrees', '60deg', 'deg', AdditionalPropInfo='')
					CheckboxProp('InElecDeg', 'D', 'Check to define RotAngMax in elec. degrees, uncheck in mech. degrees', false)
					VariablePropNU('RotAngIntervals', 'D', 'Number of uniform sweeping intervals for rotating angle', '12', '', AdditionalPropInfo='')
					VariablePropNU('SkewAng', 'D', 'Skew angle of the stator or rotor core for 2D only, in mechanical degrees', '0deg', 'deg', AdditionalPropInfo='')
					VariablePropNU('Poles', 'D', 'Number of poles', '2', '', AdditionalPropInfo='')
					VariablePropNU('Slots', 'HD', 'Number of stator slots to determine cogging torque period', '0', '', AdditionalPropInfo='')
					VariablePropNU('Output', 'HD', '0: ABC flux output; 1: DQ0 flux output; 2: LdLqFm output', '1', '', AdditionalPropInfo='')
					ButtonProp('MaxCirNetList', 'HD', '', '.MODEL @DeviceName ECER (RAngM=@RotAngMax EDeg=@InElecDeg RAngN=@RotAngIntervals Skew=@SkewAng Poles=@Poles Slots=@Slots DQOutput=@Output)', '.MODEL @DeviceName ECER (RAngM=@RotAngMax EDeg=@InElecDeg RAngN=@RotAngIntervals Skew=@SkewAng Poles=@Poles Slots=@Slots DQOutput=@Output)', 1, ButtonPropClientData())
				$end 'Parameters'
			$end 'ECER_Model'
		$end 'Compdefs'
	$end 'Definitions'
	DesignIDServer=2
	MoveBackwards=false
	$begin 'MaxCirCircuit'
		RepRewriteV2=true
		Name='ECE_Reference'
		DesignID=0
		$begin 'Circuit'
			ComponentName='ECE_Reference'
			AutoFP=''
			$begin 'DesignDatasets'
				NextUniqueID=0
				MoveBackwards=false
				DatasetType='DesignDatasetType'
				$begin 'DatasetDefinitions'
				$end 'DatasetDefinitions'
			$end 'DesignDatasets'
			VariableOrders[0:]
			$begin 'Compinst'
				ID='1'
				Status='Status'
				CompName='Maxwell Circuit Elements\\Dedicated Elements:ECE3_Model'
				$begin 'Properties'
					TextProp('ID', 'SRID', '', '1')
				$end 'Properties'
				$begin 'Parameters'
					TextProp('Windings', 'OD', 'Comma-separated phase winding list in sequence order', 'WG_Ph1_P1,WG_Ph2_P1,WG_Ph3_P1')
					TextProp('CurrentSweeps', 'OD', 'Positive current amplitude sweeping list. Format "v1, v2, (dv1, n1), v3, (dv2, n2), v4, ..."', '0A,1A')
					NumberProp('PhAngIntervals', 'OD', '(0, 1, 2) for DQ sweeps; 3 for 2-phase sweeps; (>=12) for current & phase angle sweeps, where the value is the number of sweep intervals for phase angle from 0 to 360 electric degrees.', 2, false)
				$end 'Parameters'
			$end 'Compinst'
			$begin 'Compinst'
				ID='2'
				Status='Status'
				CompName='Maxwell Circuit Elements\\Dedicated Elements:ECER_Model'
				$begin 'Properties'
					TextProp('ID', 'SRID', '', '2')
				$end 'Properties'
				$begin 'Parameters'
					ValuePropNU('Poles', 'OD', 'Number of poles', '8', 0, '', AdditionalPropInfo='')
					ValuePropNU('Slots', 'OHD', 'Number of stator slots to determine cogging torque period', '0', 0, '', AdditionalPropInfo='')
					ValuePropNU('RotAngMax', 'OD', 'Maximum rotating angle for sweeping in mech. or elec. degrees', '360deg', 0, 'deg', AdditionalPropInfo='')
					ValuePropNU('RotAngIntervals', 'OD', 'Number of uniform sweeping intervals for rotating angle', '12', 0, '', AdditionalPropInfo='')
				$end 'Parameters'
			$end 'Compinst'
			$begin 'GlobalPort'
				PortName='0'
			$end 'GlobalPort'
			$begin 'Net'
				NetName='0'
				NetGPorts='0'
			$end 'Net'
		$end 'Circuit'
		$begin 'Schematic'
			PPortCounter=0
			BusEntryCounter=0
			ShowVariableBlock=true
			$begin 'Page'
				PageSize('A')
				PageData(Origin(x='0mm', y='0mm'), PageSize(x='0', y='0'), Margins(x='0', y='0'), 0, 0, 0)
				PageNumber=1
				$begin 'SchGPort'
					SchPortInst('Symbols:ground_earth', '0', '0', 12, 0, -0.0508, 0, false, 'Symbols:ground_earth', 0)
					$begin 'PropDisplayMap'
						PortName(2, 5, 0, Text(0.00127, -0.0508, 0, 1, 5, false, 'Arial', 0, '0', false, false, ExtentRect(0, 0, 0, 0, 0.00168776315789641, -0.049918055555552, 0.000835526315792816, 0.00176388888889594, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'SchGPort'
				$begin 'SchCompDef'
					SchCompInst('Maxwell Circuit Elements\\Dedicated Elements:ECE3_Model', 'A', '1', 1, '1', 'normal', 0, 0, 0, false, 4294967295, true)
					Levels(0, 1)
				$end 'SchCompDef'
				$begin 'SchCompDef'
					SchCompInst('Maxwell Circuit Elements\\Dedicated Elements:ECER_Model', 'A', '2', 3, '2', 'normal', 0.0508, 0, 0, false, 4294967295, true)
					Levels(0, 1)
				$end 'SchCompDef'
				$begin 'PageNet'
					NetName='0'
					ID=14
					Global('0', 12)
					Color=16711680
				$end 'PageNet'
				$begin 'Properties'
					TextProp('Title', 'D', '', '')
					TextProp('Author', 'D', '', '')
					TextProp('Number', 'D', '', '')
					TextProp('Project', 'D', '', '')
					TextProp('ProjectPath', 'D', '', '')
					TextProp('Design', 'D', '', '')
					TextProp('Date', 'D', '', '')
				$end 'Properties'
			$end 'Page'
			GridSetup('1000mil', '100mil', '100mil', 16772075, 16774645, true, true, 16777215, Origin(x='0mm', y='0mm'), PageSize(x='0mm', y='0mm'), Margins(x='0mm', y='0mm'), 0, 0, 0)
			NextUniqueID=0
			MoveBackwards=false
		$end 'Schematic'
		Notes=$begin_cdata$ $end_cdata$
	$end 'MaxCirCircuit'
	$begin 'DataInstances'
		DesignEditor='TopLevel'
		Refdes('0', 'U1')
		$begin 'CompInstances'
			$begin 'Compinst'
				ID='0'
				Status='Status'
				CompName='ECE_Reference'
				GatesInUse()
				$begin 'Properties'
					TextProp('ID', 'SRID', '', '0')
				$end 'Properties'
			$end 'Compinst'
		$end 'CompInstances'
		$begin 'Instance'
			DesignEditor='ECE_Reference'
			ID='0'
			Refdes('1', 'U1')
			Refdes('2', 'U2')
			$begin 'MaxCirCircuit'
				DesignInstanceID=1
			$end 'MaxCirCircuit'
		$end 'Instance'
		$begin 'SODInfo'
		$end 'SODInfo'
	$end 'DataInstances'
	$begin 'WBSystemIDToDesignInstanceIDMap'
	$end 'WBSystemIDToDesignInstanceIDMap'
	$begin 'WBSysIDSysDetails'
	$end 'WBSysIDSysDetails'
	$begin 'WBConnIDConnDetails'
	$end 'WBConnIDConnDetails'
	$begin 'WBMaterialGuidDetails'
		WBMaterialGuidMap()
	$end 'WBMaterialGuidDetails'
	$begin 'MinervaProjectSettingsBlk'
		MinervaRemoteFilePath=''
		FolderContainerString=''
	$end 'MinervaProjectSettingsBlk'
$end 'AnsoftProject'
$begin 'AllReferencedFilesForProject'
$end 'AllReferencedFilesForProject'
$begin 'ProjectPreview'
	ProductName='ElectronicsDesktop'
	MajorVersion=2026
	MinorVersion=1
	IsEncrypted=false
	Thumbnail64=''
	$begin 'DesignInfo'
		DesignName='ECE_Reference'
		Notes=''
		Factory='Maxwell Circuit'
		IsSolved=false
		'Nominal Setups'[0:]
		'Nominal Setup Types'[0:]
		'Optimetrics Setups'[0:]
		'Optimetrics Experiment Types'[0:]
		Image64=''
	$end 'DesignInfo'
$end 'ProjectPreview'
